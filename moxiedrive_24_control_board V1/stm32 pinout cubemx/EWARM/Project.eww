<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32 pinout cubemx V2.ewp</path>
  </project>
  <batchBuild />
</workspace>
